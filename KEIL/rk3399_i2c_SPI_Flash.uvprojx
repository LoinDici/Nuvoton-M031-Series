# Keil uVision project rk3399_i2c_SPI_Flash.uvprojx, settings and files
target rk3399_i2c_SPI_Flash (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: M031FB0AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x800) IROM(0x00000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: rk3399_i2c_SPI_Flash +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c define: xxDEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\..\Library\StdDriver\inc;..\..\rk3399_i2c_SPI_Flash
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c uart.c spi.c gpio.c
    ../../../Library/StdDriver/src/: i2c.c timer.c
  group User
    ../: main.c i2c_transfer.c spi_transfer.c
    ./: power.c
software components: CMSIS:CORE 5.4.0
